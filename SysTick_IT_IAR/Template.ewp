# IAR project Template.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C123GH6PM TexasInstruments TM4C123GH6PM
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: TM4C123GH6PM
  ICCARM.CCIncludePath2: C:\ti\TivaWare_C_Series-2.2.0.295; Drivers\CMSIS\Include; \Drivers\CMSIS\Device\TI\TM4C123\Inc; $PROJ_DIR$
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkAdditionalLibs: D:\TRABAJO\UMAKER\CURSOS\ARM - TIVA C - AGOSTO\TIVA-C_Source\ClockControl\driverlib.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Core/Inc
    ./: Delay.h PLL.h
  group Core/Scr
    ./: Delay.c main.c PLL.c startup_ewarm.c TM4C123_it.c
  group Drivers/CMSIS
    Drivers/CMSIS/Device/TI/TM4C123/Scr/: system_TM4C123.c
